options:
  parameters:
    author: kwon
    generate_options: qt_gui
    id: goal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.2'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '915000000'
    gain1: '''manual'''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '20000000'
    type: fc32
    uri: 192.168.3.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '20000000'
    fc: '915000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '64'
    srate: '20000000'
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_sub_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', zeromq_pub_sink_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
